# Keil uVision project STM32L4xx.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L4xx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _KEIL, STM32L432, _HSE_CLK=8000, _HSE_BYPASS_OFF
  c include: .\Src;.\Lib;.\Lib\Sys;.\Lib\Sys\MDK
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Src
    ./src/: main.c
  group Lib
    ./Lib/: uart.h port.h uart.c timer.c port.c
    ./Lib/Sys/: system_stm32l4xx.c
    ./Lib/Sys/MDK/: startup_stm32f4xx.s
